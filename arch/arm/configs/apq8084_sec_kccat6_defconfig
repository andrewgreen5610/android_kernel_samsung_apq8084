## arch/arm/configs/apq8084_sec_lentislte_defconfig
```kconfig
CONFIG_SEC_LENTIS_PROJECT=y
CONFIG_MACH_LENTISLTE_SKT=y
CONFIG_MACH_LENTISLTE_KTT=y
CONFIG_MACH_LENTISLTE_LGT=y
```
